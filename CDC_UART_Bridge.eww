<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CDC_UART_Bridge_F5509.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\CDC_UART_Bridge_F6638.ewp</path>
  </project>
  <batchBuild/>
</workspace>


